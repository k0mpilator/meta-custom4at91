SRCREV = "87c9c5ccc831218312d8ce0ff84dd938c0ae7baa"
COMPATIBLE_MACHINE .= "|sama5d27-som1-custom"
SRC_URI = "git://github.com/k0mpilator/u-boot-at91.git;protocol=https;branch=${UBRANCH}"
