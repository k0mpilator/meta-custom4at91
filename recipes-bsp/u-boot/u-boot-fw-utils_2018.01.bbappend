SRCREV = "c5d8c7a119751654bc9e8789476256247f617021"
LIC_FILES_CHKSUM = "file://README;beginline=1;endline=22;md5=9915e8cb100eb5dbb366010a0f10296c"
 
SRC_URI = "git://github.com/k0mpilator/u-boot-at91.git;protocol=https;branch=u-boot-2018.07-at91"
