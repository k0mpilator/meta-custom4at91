COMPATIBLE_MACHINE .= "|sama5d27-som1-custom"